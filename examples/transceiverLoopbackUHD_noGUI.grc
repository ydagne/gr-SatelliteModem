<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiverLoopbackUHD_noGUI</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_configuration</key>
<param><key>id</key><value>modemConfiguration</value></param>
<param><key>value</key><value>{'encoder' : 'cc','rate' : 0.5, 'arity' : 4, 'excessBW' : 0.35, 'preambleOverhead' : 8, 'MTU' : 100}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxFreq</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxGain</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxUDPPort</value></param>
<param><key>value</key><value>9002</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txFreq</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txGain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>txUDPPort</value></param>
<param><key>value</key><value>9001</value></param>
</block>
<block>
<key>SatelliteModem_DPSKReceiver</key>
<param><key>id</key><value>SatelliteModem_DPSKReceiver_0</value></param>
<param><key>arity</key><value>modemConfiguration['arity']</value></param>
<param><key>excessBW</key><value>modemConfiguration['excessBW']</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>SatelliteModem_DPSKTransmitter</key>
<param><key>id</key><value>SatelliteModem_DPSKTransmitter_0</value></param>
<param><key>amplitude</key><value>.1</value></param>
<param><key>arity</key><value>modemConfiguration['arity']</value></param>
<param><key>excessBW</key><value>modemConfiguration['excessBW']</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>SatelliteModem_Deframer</key>
<param><key>id</key><value>SatelliteModem_Deframer_0</value></param>
<param><key>MTU</key><value>modemConfiguration['MTU']</value></param>
</block>
<block>
<key>SatelliteModem_Depacketizer</key>
<param><key>id</key><value>SatelliteModem_Depacketizer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>MTU</key><value>modemConfiguration['MTU']</value></param>
<param><key>UDPPort</key><value>rxUDPPort</value></param>
</block>
<block>
<key>SatelliteModem_FECDecoder</key>
<param><key>id</key><value>SatelliteModem_FECDecoder_0</value></param>
<param><key>type</key><value>modemConfiguration['encoder']</value></param>
<param><key>pktLen</key><value>modemConfiguration['MTU']+6</value></param>
<param><key>rate</key><value>modemConfiguration['rate']</value></param>
</block>
<block>
<key>SatelliteModem_FECEncoder</key>
<param><key>id</key><value>SatelliteModem_FECEncoder_0</value></param>
<param><key>type</key><value>modemConfiguration['encoder']</value></param>
<param><key>pktLen</key><value>modemConfiguration['MTU']+6</value></param>
<param><key>rate</key><value>modemConfiguration['rate']</value></param>
</block>
<block>
<key>SatelliteModem_Framer</key>
<param><key>id</key><value>SatelliteModem_Framer_0</value></param>
<param><key>MTU</key><value>modemConfiguration['MTU']</value></param>
<param><key>nonBlocking</key><value>1</value></param>
</block>
<block>
<key>SatelliteModem_Packetizer</key>
<param><key>id</key><value>SatelliteModem_Packetizer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>MTU</key><value>modemConfiguration['MTU']</value></param>
<param><key>nonBlocking</key><value>1</value></param>
<param><key>UDPPort</key><value>txUDPPort</value></param>
</block>
<block>
<key>SatelliteModem_PreambleDetector</key>
<param><key>id</key><value>SatelliteModem_PreambleDetector_0</value></param>
<param><key>payloadLength</key><value>int((modemConfiguration['MTU']+6)/modemConfiguration['rate'])</value></param>
<param><key>overheadBytes</key><value>modemConfiguration['preambleOverhead']</value></param>
</block>
<block>
<key>SatelliteModem_SyncPreamble</key>
<param><key>id</key><value>SatelliteModem_SyncPreamble_0</value></param>
<param><key>payloadLength</key><value>int((modemConfiguration['MTU']+6)/modemConfiguration['rate'])</value></param>
<param><key>overheadBytes</key><value>modemConfiguration['preambleOverhead']</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0</value></param>
<param><key>dont_block</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>rxUDPPort</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>modemConfiguration['MTU']</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>modemConfiguration['MTU']</value></param>
<param><key>port</key><value>txUDPPort</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>name</key><value>"TX"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>name</key><value>"RX"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>"Soft bits"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>"Frame"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>txFreq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>txGain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rxFreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rxGain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>SatelliteModem_DPSKReceiver_0</source_block_id><sink_block_id>SatelliteModem_PreambleDetector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_DPSKReceiver_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_DPSKTransmitter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_DPSKTransmitter_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_Deframer_0</source_block_id><sink_block_id>blocks_message_source_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>SatelliteModem_FECDecoder_0</source_block_id><sink_block_id>SatelliteModem_Deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_FECDecoder_0</source_block_id><sink_block_id>SatelliteModem_Depacketizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_FECEncoder_0</source_block_id><sink_block_id>SatelliteModem_SyncPreamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_Framer_0</source_block_id><sink_block_id>SatelliteModem_FECEncoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_Packetizer_0</source_block_id><sink_block_id>SatelliteModem_FECEncoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_PreambleDetector_0</source_block_id><sink_block_id>SatelliteModem_FECDecoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_PreambleDetector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SatelliteModem_SyncPreamble_0</source_block_id><sink_block_id>SatelliteModem_DPSKTransmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0</source_block_id><sink_block_id>SatelliteModem_Framer_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_source_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_message_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>SatelliteModem_DPSKReceiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
